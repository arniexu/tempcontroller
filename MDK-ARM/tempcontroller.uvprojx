# Keil uVision project tempcontroller.uvprojx, settings and files
target tempcontroller (6110000::V6.11::ARMCLANG)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  output: tempcontroller
  group Application
    ..//Core//Src//: main.c stm32f1xx_hal_msp.c
