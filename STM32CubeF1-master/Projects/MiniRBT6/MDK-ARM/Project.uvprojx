# Keil uVision project Project.uvprojx, settings and files
target TempController (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: TempController
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Inc;../BSP/Inc;../ThirdParty/Graphics/Inc;../ThirdParty/Fonts/Inc;../App/Inc;../../../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../../../Drivers/STM32F1xx_HAL_Driver/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --diag_suppress=L6329
  group Drivers/STM32F1xx_HAL_Driver
    ../../../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_gpio.c stm32f1xx_hal_cortex.c
  group Example/User
    ../Src/: stm32f1xx_hal_msp.c main.c stm32f1xx_it.c
  group BSP
    ../BSP/Src/: bsp_oled.c bsp_lcd8080.c
  group ThirdParty/Fonts
    ../ThirdParty/Fonts/Src/: font16.c lcd_font_zh.c
  group ThirdParty/Graphics
    ../ThirdParty/Graphics/Src/: tinygfx.c
  group App
    ../App/Src/: app_demo.c
  group Doc
    ../: readme.txt
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Example/MDK-ARM
    ./: startup_stm32f103xb.s
software components: CMSIS:CORE 5.3.0
