# Keil uVision project TempController.uvprojx, settings and files
target TempController_STM32F103RB (5060750::V5.06 update 7 (build 750)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20005000) IROM(0x08000000-0x08020000) CLOCK(8000000) CPUTYPE("Cortex-M3") FPU2 NOEMI
  output: tempcontroller +hex
  c misc: --c99
  group Core
    ../Core/Src/: tempcontroller_app.c tempcontroller_pid_autotune.c
  group Drivers
    ../Drivers/ADS1220/: ads1220.c
    ../Drivers/EC11/: ec11.c
    ../Drivers/OLED96X96/: oled96x96_i2c.c
