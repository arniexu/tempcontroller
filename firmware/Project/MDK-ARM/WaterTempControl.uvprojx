# Keil uVision project WaterTempControl.uvprojx, settings and files
target Debug-HWTest (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: WaterTempControl_Debug-HWTest
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB,APP_BUILD_DEBUG=1,APP_HW_DRIVER_TEST_DISPLAY=1
  c include: ..\..\Core\Inc;..\..\Drivers\BSP;..\..\ThirdParty\lvgl;..\..\ThirdParty\STM32CubeF1\Drivers\STM32F1xx_HAL_Driver\Inc;..\..\ThirdParty\STM32CubeF1\Drivers\STM32F1xx_HAL_Driver\Inc\Legacy;..\..\ThirdParty\STM32CubeF1\Drivers\CMSIS\Include;..\..\ThirdParty\STM32CubeF1\Drivers\CMSIS\Device\ST\STM32F1xx\Include
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group BSP
    ../../Drivers/BSP/: bsp_ds18b20.c bsp_relay.c bsp_rtc.c bsp_uart.c bsp_key.c bsp_lcd_8080.c bsp_lcd_font.c bsp_systick.c bsp_buzzer.c bsp_eeprom.c bsp_spiflash.c
  group CORE
    ../../Core/Src/: alarm_service.c app_main.c debug_log.c heater_ctrl.c log_service.c network_service.c main.c param_store.c pid_ctrl.c protocol_export.c schedule_service.c scheduler.c temp_manager.c tune_service.c ui_key_input.c ui_service.c ui_lvgl_port.c ui_lvgl_view.c
  group LVGL
    ../../ThirdParty/lvgl/src/core/: lv_group.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_id_builtin.c lv_obj_pos.c lv_obj_property.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_observer.c lv_refr.c
    ../../ThirdParty/lvgl/src/display/: lv_display.c
    ../../ThirdParty/lvgl/src/draw/: lv_draw.c lv_draw_3d.c lv_draw_arc.c lv_draw_blur.c lv_draw_buf.c lv_draw_image.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_draw_vector.c lv_image_decoder.c
    ../../ThirdParty/lvgl/src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend_to_a8.c lv_draw_sw_blend_to_al88.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_argb8888_premultiplied.c lv_draw_sw_blend_to_i1.c lv_draw_sw_blend_to_l8.c lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb565_swapped.c lv_draw_sw_blend_to_rgb888.c
    ../../ThirdParty/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blur.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_grad.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask_rect.c lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_utils.c lv_draw_sw_vector.c
    ../../ThirdParty/lvgl/src/font/: lv_font.c lv_font_montserrat_14.c lv_font_montserrat_20.c
    ../../ThirdParty/lvgl/src/indev/: lv_gridnav.c lv_indev.c lv_indev_gesture.c lv_indev_scroll.c
    ../../ThirdParty/lvgl/src/layouts/: lv_layout.c
    ../../ThirdParty/lvgl/src/: lv_init.c
    ../../ThirdParty/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_array.c lv_async.c lv_bidi.c lv_circle_buf.c lv_color.c lv_color_op.c lv_event.c lv_fs.c lv_grad.c lv_iter.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_matrix.c lv_palette.c lv_pending.c lv_profiler_builtin.c lv_profiler_builtin_posix.c lv_rb.c lv_style.c lv_style_gen.c lv_templ.c lv_text.c lv_text_ap.c lv_timer.c lv_tree.c lv_utils.c
    ../../ThirdParty/lvgl/src/osal/: lv_os.c lv_os_none.c
    ../../ThirdParty/lvgl/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c
    ../../ThirdParty/lvgl/src/stdlib/clib/: lv_mem_core_clib.c lv_sprintf_clib.c lv_string_clib.c
    ../../ThirdParty/lvgl/src/stdlib/: lv_mem.c
    ../../ThirdParty/lvgl/src/themes/: lv_theme.c
    ../../ThirdParty/lvgl/src/themes/simple/: lv_theme_simple.c
    ../../ThirdParty/lvgl/src/themes/mono/: lv_theme_mono.c
    ../../ThirdParty/lvgl/src/draw/convert/: lv_draw_buf_convert.c
    ../../ThirdParty/lvgl/src/font/fmt_txt/: lv_font_fmt_txt.c
    ../../ThirdParty/lvgl/src/layouts/flex/: lv_flex.c
    ../../ThirdParty/lvgl/src/layouts/grid/: lv_grid.c
    ../../ThirdParty/lvgl/src/libs/bin_decoder/: lv_bin_decoder.c
    ../../ThirdParty/lvgl/src/misc/cache/: lv_cache.c lv_cache_entry.c
    ../../ThirdParty/lvgl/src/misc/cache/class/: lv_cache_lru_rb.c
    ../../ThirdParty/lvgl/src/misc/cache/instance/: lv_image_cache.c lv_image_header_cache.c
    ../../ThirdParty/lvgl/src/tick/: lv_tick.c
    ../../ThirdParty/lvgl/src/widgets/button/: lv_button.c
    ../../ThirdParty/lvgl/src/widgets/label/: lv_label.c
  group CMSIS
    ../../ThirdParty/STM32CubeF1/Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
    ../../ThirdParty/STM32CubeF1/Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xb.s
  group HAL
    ../../ThirdParty/STM32CubeF1/Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_crc.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_spi.c stm32f1xx_hal_i2c.c
target Release (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: as above
  output: WaterTempControl
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB,APP_BUILD_RELEASE=1
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
